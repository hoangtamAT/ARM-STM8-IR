# IAR project IR.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003F3 STM8S003F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S003
  ICCSTM8.CCIncludePath2: E:\TAM\K\ARM\STM8\PROJECT\IR\User; E:\TAM\K\ARM\STM8\PROJECT\IR\Library\inc
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: IR.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Library
    ../Library/src/: IR.c stm8s_clk.c stm8s_gpio.c
  group User
    ../User/: main.c stm8s_conf.h stm8s_it.c stm8s_it.h
